do_install_append() {
	chmod 0700 ${D}/home/root
}
