# Disable faac and faad2 as the have commercial licenses
PACKAGECONFIG_remove_dumpling-wayland-rzg2 = " faac faad"
