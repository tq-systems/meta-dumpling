# extends fsl-image-multimedia-full with additional tools

LICENSE = "MIT"

require recipes-fsl/images/fsl-image-multimedia-full.bb
require recipes-images/images/tq-image.inc
require fsl_image_append.inc
