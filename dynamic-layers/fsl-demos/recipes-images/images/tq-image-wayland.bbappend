
IMAGE_INSTALL += "\
  packagegroup-fsl-gstreamer1.0 \
"
