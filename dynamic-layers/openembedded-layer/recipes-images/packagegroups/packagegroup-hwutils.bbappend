RDEPENDS_${PN}_append = " \
    spitools \
    lmsensors-sensors \
    libgpiod \
    uhubctl \
    usb-modeswitch \
"
